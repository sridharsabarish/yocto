# Set package version revision and epoch
PV = "1.0+git${SRCPV}"
PR = "r1"
PE = "1"
