do_trouble(){
    bberror "Here, Comes Trouble"
}

addtask trouble after compile